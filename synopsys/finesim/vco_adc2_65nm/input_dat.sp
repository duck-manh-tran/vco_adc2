.DATA input_signal
+ vin_amp
+ 0.1
.ENDDATA
